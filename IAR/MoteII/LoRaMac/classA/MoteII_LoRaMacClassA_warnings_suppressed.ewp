# IAR project MoteII_LoRaMacClassA_warnings_suppressed.ewp, settings and files
configuration MoteII_LoRaMacClassA-AS923 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L051C8 ST STM32L051C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: REGION_AS923; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe301,Pe826,Pe193,Pa093,Pa091,Pe068,Pe1348,Pe177,Pe1873
  ICCARM.CCIncludePath2: ..\..\..\..\src; ..\..\..\..\src\boards\MoteII; ..\..\..\..\src\boards\MoteII\cmsis; ..\..\..\..\src\boards\mcu\stm32; ..\..\..\..\src\boards\mcu\stm32\cmsis; ..\..\..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc; ..\..\..\..\src\mac; ..\..\..\..\src\mac\region; ..\..\..\..\src\peripherals; ..\..\..\..\src\radio; ..\..\..\..\src\system; ..\..\..\..\src\system\crypto
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MoteII_LoRaMacClassA.srec
  ILINK.IlinkOutputFile: MoteII_LoRaMacClassA.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MoteII_LoRaMacClassA-AU915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_AU915; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-CN470 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_CN470; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-CN779 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_CN779; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-EU433 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_EU433; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-EU868 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_EU868; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-KR920 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_KR920; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-IN865 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_IN865; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-US915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_US915; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
configuration MoteII_LoRaMacClassA-US915_HYBRID (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_US915_HYBRID; USE_MODEM_LORA; STM32L051xx; USE_HAL_DRIVER
  group apps
    ../../../../src/apps/LoRaMac/classA/MoteII/: buttons.c main.c screen.c
  group boards/mcu/stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group boards/MoteII
    ../../../../src/boards/MoteII/: adc-board.c board.c display-board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c
  group boards/MoteII/cmsis
    ../../../../src/boards/MoteII/cmsis/arm-std/: startup_stm32l051xx.s
    ../../../../src/boards/MoteII/cmsis/: system_stm32l0xx.c
  group boards/MoteII/STM32L0xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group mac/region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group peripherals
    ../../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c pam7q.c sx1509.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
  group system/crypto
    ../../../../src/system/crypto/: aes.c cmac.c
