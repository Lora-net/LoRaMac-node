<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LoRaMote\Bootloader\LoRaMote_Bootloader_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoRaMote\LoRaMac\classA\LoRaMote_LoRaMacClassA_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoRaMote\LoRaMac\classB\LoRaMote_LoRaMacClassB_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoRaMote\LoRaMac\classC\LoRaMote_LoRaMacClassC_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoRaMote\ping-pong\LoRaMote_Ping-Pong_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoRaMote\rx-sensi\LoRaMote_rx-sensi_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\LoRaMote\tx-cw\LoRaMote_tx-cw_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MoteII\LoRaMac\classA\MoteII_LoRaMacClassA_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MoteII\LoRaMac\classB\MoteII_LoRaMacClassB_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MoteII\LoRaMac\classC\MoteII_LoRaMacClassC_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MoteII\ping-pong\MoteII_Ping-Pong_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MoteII\rx-sensi\MoteII_rx-sensi_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\MoteII\tx-cw\MoteII_tx-cw_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NAMote72\LoRaMac\classA\NAMote72_LoRaMacClassA_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NAMote72\LoRaMac\classB\NAMote72_LoRaMacClassB_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NAMote72\LoRaMac\classC\NAMote72_LoRaMacClassC_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NAMote72\ping-pong\NAMote72_Ping-Pong_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NAMote72\rx-sensi\NAMote72_rx-sensi_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\NAMote72\tx-cw\NAMote72_tx-cw_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\Bootloader\SensorNode_Bootloader_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\LoRaMac\classA\SensorNode_LoRaMacClassA_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\LoRaMac\classB\SensorNode_LoRaMacClassB_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\LoRaMac\classC\SensorNode_LoRaMacClassC_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\ping-pong\SensorNode_Ping-Pong_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\rx-sensi\SensorNode_rx-sensi_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SensorNode\tx-cw\SensorNode_tx-cw_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SK-iM880A\LoRaMac\classA\SK-iM880A_LoRaMacClassA_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SK-iM880A\LoRaMac\classB\SK-iM880A_LoRaMacClassB_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SK-iM880A\LoRaMac\classC\SK-iM880A_LoRaMacClassC_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SK-iM880A\ping-pong\SK-iM880A_Ping-Pong_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SK-iM880A\rx-sensi\SK-iM880A_rx-sensi_warnings_active.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\SK-iM880A\tx-cw\SK-iM880A_tx-cw_warnings_active.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>LoRaMote</name>
            <member>
                <project>LoRaMote_Bootloader_warnings_active</project>
                <configuration>LoRaMote_Bootloader</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>MoteII</name>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-US915</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>NAMote72</name>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-US915</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>SensorNode</name>
            <member>
                <project>SensorNode_Bootloader_warnings_active</project>
                <configuration>SensorNode_Bootloader</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-US915</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>SK-iM880A</name>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_AS923</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-AS923</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_AU915</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-AU915</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_CN470</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-CN470</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_CN779</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-CN779</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_EU433</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-EU433</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_EU868</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-EU868</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_IN865</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-IN865</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_KR920</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-KR920</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_US915</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-US915</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All_US915_HYBRID</name>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>ZZZ-Everything-ZZZ</name>
            <member>
                <project>LoRaMote_Bootloader_warnings_active</project>
                <configuration>LoRaMote_Bootloader</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassA_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassB_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_LoRaMacClassC_warnings_active</project>
                <configuration>LoRaMote_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_Ping-Pong_warnings_active</project>
                <configuration>LoRaMote_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_rx-sensi_warnings_active</project>
                <configuration>LoRaMote_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-US915</configuration>
            </member>
            <member>
                <project>LoRaMote_tx-cw_warnings_active</project>
                <configuration>LoRaMote_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassA_warnings_active</project>
                <configuration>MoteII_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassB_warnings_active</project>
                <configuration>MoteII_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>MoteII_LoRaMacClassC_warnings_active</project>
                <configuration>MoteII_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>MoteII_Ping-Pong_warnings_active</project>
                <configuration>MoteII_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>MoteII_rx-sensi_warnings_active</project>
                <configuration>MoteII_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-US915</configuration>
            </member>
            <member>
                <project>MoteII_tx-cw_warnings_active</project>
                <configuration>MoteII_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassA_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassB_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>NAMote72_LoRaMacClassC_warnings_active</project>
                <configuration>NAMote72_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>NAMote72_Ping-Pong_warnings_active</project>
                <configuration>NAMote72_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>NAMote72_rx-sensi_warnings_active</project>
                <configuration>NAMote72_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-US915</configuration>
            </member>
            <member>
                <project>NAMote72_tx-cw_warnings_active</project>
                <configuration>NAMote72_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_Bootloader_warnings_active</project>
                <configuration>SensorNode_Bootloader</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassA_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassB_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>SensorNode_LoRaMacClassC_warnings_active</project>
                <configuration>SensorNode_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>SensorNode_Ping-Pong_warnings_active</project>
                <configuration>SensorNode_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>SensorNode_rx-sensi_warnings_active</project>
                <configuration>SensorNode_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-US915</configuration>
            </member>
            <member>
                <project>SensorNode_tx-cw_warnings_active</project>
                <configuration>SensorNode_tx-cw-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassA_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassA-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassB_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassB-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_LoRaMacClassC_warnings_active</project>
                <configuration>SK-iM880A_LoRaMacClassC-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_Ping-Pong_warnings_active</project>
                <configuration>SK-iM880A_Ping-Pong-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_rx-sensi_warnings_active</project>
                <configuration>SK-iM880A_rx-sensi-US915_HYBRID</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-AS923</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-AU915</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-CN470</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-CN779</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-EU433</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-EU868</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-IN865</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-KR920</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-US915</configuration>
            </member>
            <member>
                <project>SK-iM880A_tx-cw_warnings_active</project>
                <configuration>SK-iM880A_tx-cw-US915_HYBRID</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>