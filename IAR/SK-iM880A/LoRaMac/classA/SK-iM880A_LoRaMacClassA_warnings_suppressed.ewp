# IAR project SK-iM880A_LoRaMacClassA_warnings_suppressed.ewp, settings and files
configuration SK-iM880A_LoRaMacClassA-AS923 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: REGION_AS923; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe301,Pe826,Pe193,Pa093,Pa091,Pe068,Pe1348,Pe177,Pe1873
  ICCARM.CCIncludePath2: ..\..\..\..\src; ..\..\..\..\src\boards\SK-iM880A; ..\..\..\..\src\boards\SK-iM880A\cmsis; ..\..\..\..\src\boards\mcu\stm32; ..\..\..\..\src\boards\mcu\stm32\cmsis; ..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\src\mac; ..\..\..\..\src\mac\region; ..\..\..\..\src\peripherals; ..\..\..\..\src\radio; ..\..\..\..\src\system; ..\..\..\..\src\system\crypto
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SK-iM880A_LoRaMacClassA.srec
  ILINK.IlinkOutputFile: SK-iM880A_LoRaMacClassA.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SK-iM880A_LoRaMacClassA-AU915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_AU915; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-CN470 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_CN470; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-CN779 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_CN779; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-EU433 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_EU433; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-EU868 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_EU868; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-KR920 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_KR920; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-IN865 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_IN865; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-US915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_US915; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
configuration SK-iM880A_LoRaMacClassA-US915_HYBRID (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_US915_HYBRID; USE_MODEM_LORA; STM32L151xB; USE_HAL_DRIVER
  group apps
    ../../../../src/apps/LoRaMac/classA/SK-iM880A/: main.c
  group boards/mcu/stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group boards/SK-iM880A
    ../../../../src/boards/SK-iM880A/: adc-board.c board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c
  group boards/SK-iM880A/cmsis
    ../../../../src/boards/SK-iM880A/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../../src/boards/SK-iM880A/cmsis/: system_stm32l1xx.c
  group boards/SK-iM880A/STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group mac/region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c timer.c uart.c
  group system/crypto
    ../../../../src/system/crypto/: aes.c cmac.c
