# IAR project SensorNode_Bootloader_warnings_suppressed.ewp, settings and files
configuration SensorNode_Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CB ST STM32L151CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_NO_TIMER; STM32L151xB; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe301,Pe826,Pe193,Pa093,Pa091,Pe068,Pe1348,Pe177,Pe1873,Pe2349
  ICCARM.CCIncludePath2: ..\..\..\src; ..\..\..\src\boards\SensorNode; ..\..\..\src\boards\SensorNode\cmsis; ..\..\..\src\boards\mcu\stm32; ..\..\..\src\boards\mcu\stm32\cmsis; ..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc; ..\..\..\src\mac; ..\..\..\src\mac\region; ..\..\..\src\peripherals; ..\..\..\src\radio; ..\..\..\src\system; ..\..\..\src\system\crypto; ..\..\..\src\boards\SensorNode\usb\dfu\inc; ..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Class\DFU\Inc; ..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Core\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SensorNode_Bootloader.srec
  ILINK.IlinkOutputFile: SensorNode_Bootloader.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group apps
    ../../../src/apps/BootLoader/SensorNode/: main.c
  group boards/mcu/stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group boards/SensorNode
    ../../../src/boards/SensorNode/: gpio-board.c i2c-board.c
  group boards/SensorNode/cmsis
    ../../../src/boards/SensorNode/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../src/boards/SensorNode/cmsis/: system_stm32l1xx.c
  group boards/SensorNode/STM32_USB_Device_Library/Class
    ../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group boards/SensorNode/STM32_USB_Device_Library/Core
    ../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group boards/SensorNode/STM32L1xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
  group boards/SensorNode/usb
    ../../../src/boards/SensorNode/usb/dfu/src/: usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c sx1509.c sx9500.c
  group system
    ../../../src/system/: gpio.c i2c.c
