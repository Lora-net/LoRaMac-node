# IAR project NAMote72_LoRaMacClassC_warnings_suppressed.ewp, settings and files
configuration NAMote72_LoRaMacClassC-AS923 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RC ST STM32L152RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: REGION_AS923; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pe301,Pe826,Pe193,Pa093,Pa091,Pe068,Pe1348,Pe177,Pe1873
  ICCARM.CCIncludePath2: ..\..\..\..\src; ..\..\..\..\src\boards\NAMote72; ..\..\..\..\src\boards\NAMote72\cmsis; ..\..\..\..\src\boards\mcu\stm32; ..\..\..\..\src\boards\mcu\stm32\cmsis; ..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc; ..\..\..\..\src\mac; ..\..\..\..\src\mac\region; ..\..\..\..\src\peripherals; ..\..\..\..\src\radio; ..\..\..\..\src\system; ..\..\..\..\src\system\crypto
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: NAMote72_LoRaMacClassC.srec
  ILINK.IlinkOutputFile: NAMote72_LoRaMacClassC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NAMote72_LoRaMacClassC-AU915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_AU915; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-CN470 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_CN470; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-CN779 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_CN779; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-EU433 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_EU433; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-EU868 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_EU868; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-KR920 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_KR920; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-IN865 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_IN865; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-US915 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_US915; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
configuration NAMote72_LoRaMacClassC-US915_HYBRID (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: REGION_US915_HYBRID; USE_MODEM_LORA; STM32L152xC; USE_HAL_DRIVER
  group apps
    ../../../../src/apps/LoRaMac/classC/NAMote72/: main.c
  group boards/mcu/stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group boards/NAMote72
    ../../../../src/boards/NAMote72/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c
  group boards/NAMote72/cmsis
    ../../../../src/boards/NAMote72/cmsis/arm-std/: startup_stm32l152xc.s
    ../../../../src/boards/NAMote72/cmsis/: system_stm32l1xx.c
  group boards/NAMote72/STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group mac/region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915-Hybrid.c RegionUS915.c
  group peripherals
    ../../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
  group system/crypto
    ../../../../src/system/crypto/: aes.c cmac.c
