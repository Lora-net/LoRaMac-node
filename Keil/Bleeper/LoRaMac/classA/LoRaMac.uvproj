# Keil uVision project LoRaMac.uvproj, settings and files
target LoRaMac (ARM-ADS)
  device: STM32L151RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_DEBUGGER USE_DEBUG_PINS LOW_POWER_MODE_ENABLE
  c misc: --c99 --gnu
  c include: ..\..\..\..\src;..\..\..\..\src\boards\Bleeper;..\..\..\..\src\boards\Bleeper\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group apps
    ../../../../src/apps/LoRaMac/classA/Bleeper/: main.c
  group boards\Bleeper
    ../../../../src/boards/Bleeper/: board.c delay-board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c timer-board.c
  group boards\Bleeper\cmsis
    ../../../../src/boards/Bleeper/cmsis/arm-std/: startup_stm32l1xx_hd.s
    ../../../../src/boards/Bleeper/cmsis/: system_stm32l1xx.c
  group boards\Bleeper\STM32L1xx_StdPeriph_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group peripherals
    ../../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: delay.c gpio.c i2c.c timer.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
