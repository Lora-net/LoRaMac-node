# Keil uVision project Ping-Pong.uvproj, settings and files
target Ping-Pong-lora (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards\SK-iM880A;..\..\..\src\boards\SK-iM880A\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../src/apps/ping-pong/SK-iM880A/: main.c
  group boards\SK-iM880A
    ../../../src/boards/SK-iM880A/: adc-board.c board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c timer-board.c uart-board.c
  group boards\SK-iM880A\cmsis
    ../../../src/boards/SK-iM880A/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../src/boards/SK-iM880A/cmsis/: system_stm32l1xx.c
  group boards\SK-iM880A\STM32L1xx_StdPeriph_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group radio
    ../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c timer.c uart.c
target Ping-Pong-fsk (ARM-ADS)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: Ping-Pong +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_DEBUGGER USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
