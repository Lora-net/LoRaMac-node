# Keil uVision project LoRaMac.uvproj, settings and files
target LoRaMac-eu868 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac-eu868 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_EU868
  c include: ..\..\..\..\src;..\..\..\..\src\boards\SK-iM880A;..\..\..\..\src\boards\SK-iM880A\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\mac\region;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../../src/apps/LoRaMac/classA/SK-iM880A/: main.c
  group boards\SK-iM880A
    ../../../../src/boards/SK-iM880A/: adc-board.c board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c
  group boards\SK-iM880A\cmsis
    ../../../../src/boards/SK-iM880A/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../../src/boards/SK-iM880A/cmsis/: system_stm32l1xx.c
  group boards\SK-iM880A\STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacClassB.c LoRaMacConfirmQueue.c LoRaMacCrypto.c
  group mac\region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
target LoRaMac-us915 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-us915 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_US915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-us915-hybrid (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-us915-hybrid +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_US915_HYBRID
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-cn779 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-cn779 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_CN779
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-as923 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-as923 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_AS923
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-au915 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-au915 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_AU915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-kr920 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-kr920 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_KR920
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target LoRaMac-in865 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: LoRaMac-in865 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_IN865
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
