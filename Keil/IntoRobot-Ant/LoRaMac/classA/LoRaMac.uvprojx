# Keil uVision project LoRaMac.uvprojx, settings and files
target LoRaMac-classA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRaMac
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xB,USE_MODEM_LORA,REGION_EU433,USE_USB_CDC,USE_STANDARD_LORAWAN
  c include: ..\..\..\..\src\apps\LoRaMac\classA\IntoRobot-Ant;..\..\..\..\src\boards\IntoRobot-Ant;..\..\..\..\src\boards\IntoRobot-Ant\cmsis;..\..\..\..\src\boards\IntoRobot-Ant\cmsis\arm-std;..\..\..\..\src\boards\IntoRobot-Ant\usb\cdc\inc;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\Inc\Legacy;..\..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Class\CDC\Inc;..\..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Core\Inc;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\mac\region;..\..\..\..\src\mac;..\..\..\..\src\radio\sx1276;..\..\..\..\src\radio;..\..\..\..\src\system\crypto;..\..\..\..\src\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../../src/apps/LoRaMac/classA/IntoRobot-Ant/: main.c
  group boards
    ../../../../src/boards/IntoRobot-Ant/: adc-board.c board.c eeprom-board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c uart-usb-board.c
  group boards\cmsis
    ../../../../src/boards/IntoRobot-Ant/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../../src/boards/IntoRobot-Ant/cmsis/: system_stm32l1xx.c
  group boards\usb\cdc
    ../../../../src/boards/IntoRobot-Ant/usb/cdc/src/: usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group boards\mcu\stm32\STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_msp_template.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c stm32l1xx_ll_adc.c stm32l1xx_ll_comp.c stm32l1xx_ll_crc.c stm32l1xx_ll_dac.c stm32l1xx_ll_dma.c stm32l1xx_ll_exti.c stm32l1xx_ll_fsmc.c stm32l1xx_ll_gpio.c stm32l1xx_ll_i2c.c stm32l1xx_ll_opamp.c stm32l1xx_ll_pwr.c stm32l1xx_ll_rcc.c stm32l1xx_ll_rtc.c stm32l1xx_ll_sdmmc.c stm32l1xx_ll_spi.c stm32l1xx_ll_tim.c stm32l1xx_ll_usart.c stm32l1xx_ll_utils.c
  group boards\mcu\stm32\STM32L1xx_USB_Device_Library
    ../../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group mac\region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: adc.c delay.c eeprom.c fifo.c gpio.c i2c.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
software components: CMSIS:CORE 5.0.1
