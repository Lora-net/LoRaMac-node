# Keil uVision project LoRaMac.uvprojx, settings and files
target LoRaMac-868 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRaMac
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xBA USE_DEBUGGER REGION_EU868 LORAMAC_CLASSB_ENABLED
  c include: ..\..\..\..\src;..\..\..\..\src\boards\RAK811Node;..\..\..\..\src\boards\RAK811Node\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\mac\region;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group apps
    ../../../../src/apps/LoRaMac/classB/RAK811Node/: main.c
  group boards\RAK811Node
    ../../../../src/boards/RAK811Node/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c eeprom-board.c
  group boards\RAK811Node\cmsis
    ../../../../src/boards/RAK811Node/cmsis/: system_stm32l1xx.c
    ../../../../src/boards/RAK811Node/cmsis/arm-std/: startup_stm32l151xba.s
  group boards\RAK811Node\STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacClassB.c
  group mac/region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group peripherals
    ../../../../src/peripherals/: mag3110.c mma8451.c mpl3115.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
