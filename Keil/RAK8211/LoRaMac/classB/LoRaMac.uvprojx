# Keil uVision project LoRaMac.uvprojx, settings and files
target RAK8211 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.14.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RAK8211
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG BLE_STACK_SUPPORT_REQD CONFIG_NFCT_PINS_AS_GPIOS CONFIG_GPIO_AS_PINRESET NRF52832_XXAA NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 NRF52_PAN_74 NRF_SD_BLE_API_VERSION=4 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 REGION_EU868 LORAMAC_CLASSB_ENABLED
  c include: ..\..\..\..\src\apps\LoRaMac\classB\RAK8211;..\..\..\..\src\radio;..\..\..\..\src\boards\RAK8211;..\..\..\..\src\mac;..\..\..\..\src\system\crypto;..\..\..\..\src\mac\region;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\comp;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\twi_master;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_ancs_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_ias_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\pwm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\softdevice\s132\headers\nrf52;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\cdc\acm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\hid\generic;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\msc;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\hid;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\log;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_gls;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\fstorage;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\i2s;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\gpiote;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\gpiote;..\..\..\..\src\boards\mcu\nRF52\SDK\components\boards;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\common;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_advertising;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_bas_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_hrs_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\queue;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_dtm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\toolchain\cmsis\include;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_rscs_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\uart;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\common;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_lls;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\wdt;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\bsp;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_bas;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\experimental_section_vars;..\..\..\..\src\boards\mcu\nRF52\SDK\components\softdevice\s132\headers;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_ans_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\slip;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\mem_manager;..\..\..\..\src\boards\mcu\nRF52\SDK\external\segger_rtt;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\csense_drv;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\hal;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_nus_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\rtc;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_ias;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\hid\mouse;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\ecc;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\ppi;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_dfu;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\twis_slave;..\..\..\..\src\boards\mcu\nRF52\SDK\components;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\scheduler;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_lbs;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_hts;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\delay;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\crc16;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\timer;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\util;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\pwm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\cdc;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\csense;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\rng;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\low_power_pwm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\hardfault;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_cscs;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\uart;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\fifo;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\hci;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\hid\kbd;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\spi_slave;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\lpcomp;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\timer;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\power;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\config;..\..\..\..\src\boards\mcu\nRF52\SDK\components\toolchain;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\led_softblink;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\qdec;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_cts_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\spi_master;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_nus;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_hids;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\strerror;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\pdm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\crc32;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd\class\audio;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\peer_manager;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\swi;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_tps;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_dis;..\..\..\..\src\boards\mcu\nRF52\SDK\components\device;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\nrf_ble_qwr;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\button;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\usbd;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\saadc;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_lbs_c;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_racp;..\..\..\..\src\boards\mcu\nRF52\SDK\components\toolchain\arm;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\fds;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\twi;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\clock;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_rscs;..\..\..\..\src\boards\mcu\nRF52\SDK\components\drivers_nrf\usbd;..\..\..\..\src\boards\mcu\nRF52\SDK\components\softdevice\common\softdevice_handler;..\..\..\..\src\boards\mcu\nRF52\SDK\components\ble\ble_services\ble_hrs;..\..\..\..\src\boards\mcu\nRF52\SDK\components\libraries\log\src;..\..\..\..\src\boards\mcu\nRF52\SDK\components\softdevice\s132\headers
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20001b38 size 0xe4c8
  group apps
    ../../../../src/apps/LoRaMac/classB/RAK8211/: main.c sdk_config.h ble_app.c app_config.h
  group boards\RAK8211\cmsis
    ../../../../src/boards/mcu/nRF52/SDK/components/toolchain/: system_nrf52.c
    ../../../../src/boards/mcu/nRF52/SDK/components/toolchain/arm/: arm_startup_nrf52.s
  group boards\RAK8211
    ../../../../src/boards/RAK8211/: board.c gpio-board.c rtc-board.c sx1276-board.c timer.c utilities.c spi-board.c
  group boards\RAK8211\sdk
    ../../../../src/boards/mcu/nRF52/SDK/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
    ../../../../src/boards/mcu/nRF52/SDK/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../src/boards/mcu/nRF52/SDK/components/libraries/timer/: app_timer.c
    ../../../../src/boards/mcu/nRF52/SDK/components/libraries/mem_manager/: mem_manager.c
    ../../../../src/boards/mcu/nRF52/SDK/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../src/boards/mcu/nRF52/SDK/components/libraries/strerror/: nrf_strerror.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/power/: nrf_drv_power.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../../../src/boards/mcu/nRF52/SDK/components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../src/boards/mcu/nRF52/SDK/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../src/boards/mcu/nRF52/SDK/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c LoRaMacClassB.c
  group mac/region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group radio
    ../../../../src/radio/sx1276/: sx1276.c
  group system/crypto
    ../../../../src/system/crypto/: aes.c cmac.c
  group SeggerRTT
    ../../../../src/boards/mcu/nRF52/SDK/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
