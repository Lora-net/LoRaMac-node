# Keil uVision project LoRaMac.uvproj, settings and files
target LoRaMac-us915 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LoRaMac-us915 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_US915 ACTIVE_REGION=LORAMAC_REGION_US915 LORAMAC_CLASSB_ENABLED
  c include: ..\..\..\..\src;..\..\..\..\src\boards;..\..\..\..\src\boards\NAMote72;..\..\..\..\src\boards\NAMote72\cmsis;..\..\..\..\src\boards\mcu\stm32;..\..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\..\src\mac;..\..\..\..\src\mac\region;..\..\..\..\src\peripherals;..\..\..\..\src\radio;..\..\..\..\src\system;..\..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group apps
    ../../../../src/apps/LoRaMac/classB/NAMote72/: main.c
  group boards\NAMote72
    ../../../../src/boards/NAMote72/: adc-board.c board.c delay-board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c
  group boards\NAMote72\cmsis
    ../../../../src/boards/NAMote72/cmsis/arm-std/: startup_stm32l152xc.s
    ../../../../src/boards/NAMote72/cmsis/: system_stm32l1xx.c
  group boards\NAMote72\STM32L1xx_HAL_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c
    ../../../../src/boards/mcu/: utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacClassB.c LoRaMacConfirmQueue.c LoRaMacCrypto.c
  group mac\region
    ../../../../src/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group peripherals
    ../../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
target LoRaMac-us915-hybrid (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-us915-hybrid +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_US915_HYBRID ACTIVE_REGION=LORAMAC_REGION_US915_HYBRID LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target LoRaMac-eu868 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-eu868 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_EU868 ACTIVE_REGION=LORAMAC_REGION_EU868 LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target LoRaMac-as923 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-as923 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_AS923 ACTIVE_REGION=LORAMAC_REGION_AS923 LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target LoRaMac-au915 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-au915 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_AU915 ACTIVE_REGION=LORAMAC_REGION_AU915 LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target LoRaMac-kr920 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-kr920 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_KR920 ACTIVE_REGION=LORAMAC_REGION_KR920 LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target LoRaMac-in865 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-in865 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_IN865 ACTIVE_REGION=LORAMAC_REGION_IN865 LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target LoRaMac-cn779 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: LoRaMac-cn779 +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_CN779 ACTIVE_REGION=LORAMAC_REGION_CN779 LORAMAC_CLASSB_ENABLED
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
