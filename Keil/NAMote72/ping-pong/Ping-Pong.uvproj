# Keil uVision project Ping-Pong.uvproj, settings and files
target Ping-Pong-us915-lora (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Ping-Pong-us915-lora +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_US915 USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards\NAMote72;..\..\..\src\boards\NAMote72\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group apps
    ../../../src/apps/ping-pong/NAMote72/: main.c
  group boards\NAMote72
    ../../../src/boards/NAMote72/: adc-board.c board.c delay-board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c uart-board.c
  group boards\NAMote72\cmsis
    ../../../src/boards/NAMote72/cmsis/arm-std/: startup_stm32l152xc.s
    ../../../src/boards/NAMote72/cmsis/: system_stm32l1xx.c
  group boards\NAMote72\STM32L1xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
target Ping-Pong-us915-fsk (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: Ping-Pong-us915-fsk +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_US915 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Ping-Pong-eu868-lora (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: Ping-Pong-eu868-lora +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_EU868 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
target Ping-Pong-eu868-fsk (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L152RC STMicroelectronics
  cpu: as above
  output: Ping-Pong-eu868-fsk +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L152xC REGION_EU868 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
