# Keil uVision project rx-sensi.uvproj, settings and files
target rx-sensi-433-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rx-sensi +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_MODEM_LORA
  c include: ..\..\..\src;..\..\..\src\boards\SensorNode;..\..\..\src\boards\SensorNode\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group apps
    ../../../src/apps/rx-sensi/SensorNode/: main.c
  group boards\SensorNode
    ../../../src/boards/SensorNode/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c
  group boards\SensorNode\cmsis
    ../../../src/boards/SensorNode/cmsis/arm-std/: startup_stm32l1xx_md.s
    ../../../src/boards/SensorNode/cmsis/: system_stm32l1xx.c
  group boards\SensorNode\STM32L1xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
target rx-sensi-433-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-433-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-433-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_433 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target Ping-Pong-780-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_780 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-780-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_780 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-780-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_780 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-780-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_780 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-868-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_868 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-868-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_868 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-868-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_868 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-868-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_868 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-915-lora (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_915 USE_MODEM_LORA
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-915-fsk (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_915 USE_MODEM_FSK
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-915-lora-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_915 USE_MODEM_LORA USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
target rx-sensi-915-fsk-Bootloader (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: as above
  output: rx-sensi +hex
  c flags: Optim=2 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER USE_BAND_915 USE_MODEM_FSK USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x2800
