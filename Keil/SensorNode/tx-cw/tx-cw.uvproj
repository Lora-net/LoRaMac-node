# Keil uVision project tx-cw.uvproj, settings and files
target tx-cw-eu433 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: tx-cw-eu433 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_EU433
  c include: ..\..\..\src;..\..\..\src\boards;..\..\..\src\boards\SensorNode;..\..\..\src\boards\SensorNode\cmsis;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\src\mac;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system;..\..\..\src\system\crypto
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../src/apps/tx-cw/SensorNode/: main.c
  group boards\SensorNode
    ../../../src/boards/SensorNode/: adc-board.c board.c delay-board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c
  group boards\SensorNode\cmsis
    ../../../src/boards/SensorNode/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../src/boards/SensorNode/cmsis/: system_stm32l1xx.c
  group boards\SensorNode\STM32L1xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c
    ../../../src/boards/mcu/: utilities.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../src/radio/sx1276/: sx1276.c
  group system
    ../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
target tx-cw-eu433-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-eu433 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_EU433 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
target tx-cw-cn779 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-cn779 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_CN779
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target tx-cw-cn779-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-cn779 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_CN779 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
target tx-cw-eu868 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-eu868 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_EU868
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target tx-cw-eu868-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-eu868 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_EU868 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
target tx-cw-us915 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-us915 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_US915
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target tx-cw-us915-Bootloader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: as above
  output: tx-cw-us915 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_DEBUGGER REGION_US915 USE_BOOTLOADER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
