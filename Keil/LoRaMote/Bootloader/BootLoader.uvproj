# Keil uVision project BootLoader.uvproj, settings and files
target BootLoader (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BootLoader +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER STM32L151xB USE_NO_TIMER
  c include: ..\..\..\src;..\..\..\src\boards;..\..\..\src\boards\LoRaMote;..\..\..\src\boards\LoRaMote\cmsis;..\..\..\src\boards\LoRaMote\usb\dfu\inc;..\..\..\src\boards\mcu\stm32;..\..\..\src\boards\mcu\stm32\cmsis;..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Class\DFU\inc;..\..\..\src\boards\mcu\stm32\STM32_USB_Device_Library\Core\inc;..\..\..\src\boards\mcu\stm32\STM32L1xx_HAL_Driver\inc;..\..\..\src\peripherals;..\..\..\src\radio;..\..\..\src\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group apps
    ../../../src/apps/bootloader/LoRaMote/: main.c
  group boards\LoRaMote
    ../../../src/boards/LoRaMote/: gpio-board.c i2c-board.c
  group boards\LoRaMote\cmsis
    ../../../src/boards/LoRaMote/cmsis/arm-std/: startup_stm32l151xb.s
    ../../../src/boards/LoRaMote/cmsis/: system_stm32l1xx.c
  group boards\LoRaMote\usb
    ../../../src/boards/LoRaMote/usb/dfu/src/: usbd_conf.c usbd_desc.c usbd_dfu_flash.c
  group boards\LoRaMote\STM32_USB_Device_Library\Class
    ../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group boards\LoRaMote\STM32_USB_Device_Library\Core
    ../../../src/boards/mcu/stm32/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group boards\LoRaMote\STM32L1xx_HAL_Driver
    ../../../src/boards/mcu/stm32/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c
  group boards\mcu\stm32
    ../../../src/boards/mcu/stm32/: sysIrqHandlers.c
  group peripherals
    ../../../src/peripherals/: gpio-ioe.c sx1509.c sx9500.c
  group system
    ../../../src/system/: gpio.c i2c.c
