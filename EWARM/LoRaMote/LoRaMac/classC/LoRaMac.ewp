# IAR project LoRaMac.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_DEBUGGER; _LOW_POWER_MODE_ENABLE; USE_BAND_868
  ICCARM.CCIncludePath2: ..\..\..\..\src; ..\..\..\..\src\boards\LoRaMote; ..\..\..\..\src\boards\LoRaMote\cmsis; ..\..\..\..\src\boards\mcu\stm32; ..\..\..\..\src\boards\mcu\stm32\cmsis; ..\..\..\..\src\boards\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\src\mac; ..\..\..\..\src\peripherals; ..\..\..\..\src\radio; ..\..\..\..\src\system; ..\..\..\..\src\system\crypto
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LoRaMac.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group apps
    ../../../../src/apps/LoRaMac/classC/LoRaMote/: main.c
  group boards\LoRaMote
    ../../../../src/boards/LoRaMote/: adc-board.c board.c gpio-board.c gps-board.c i2c-board.c rtc-board.c spi-board.c sx1272-board.c timer-board.c uart-board.c
  group boards\LoRaMote\cmsis
    ../../../../src/boards/LoRaMote/cmsis/arm-iar/: startup_stm32l1xx_md.s
    ../../../../src/boards/LoRaMote/cmsis/: system_stm32l1xx.c
  group boards\LoRaMote\STM32L1xx_StdPeriph_Driver
    ../../../../src/boards/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group boards\mcu\stm32
    ../../../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group peripherals
    ../../../../src/peripherals/: gpio-ioe.c mag3110.c mma8451.c mpl3115.c sx1509.c sx9500.c
  group radio
    ../../../../src/radio/sx1272/: sx1272.c
  group system
    ../../../../src/system/: adc.c delay.c fifo.c gpio.c gps.c i2c.c timer.c uart.c
  group system\crypto
    ../../../../src/system/crypto/: aes.c cmac.c
